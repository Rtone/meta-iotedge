SRC_URI += "file://0001-Change-panic-strategy.patch"

do_compile[network] = "1"

