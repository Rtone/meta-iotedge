SRC_URI += "file://0001-Fix-edgelet-iotedge-code.patch"

do_compile[network] = "1"
